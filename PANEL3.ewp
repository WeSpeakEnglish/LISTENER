# IAR project PANEL3.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; src\; board\; modules\; lib\CMSIS\Core\CM3\; lib\STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PANEL2.srec
  ILINK.IlinkOutputFile: LCD_demo.out
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: adc.c beeper.c dac.c defines.h delays.c encoder.c events.c I2Croutines.c ioconfig.c IR_control.c keyboard.c lighting.c main.c queue.c stm32f10x_conf.h timers.c timingconfig.c touchscreen.c
  group CMSIS
    lib/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md_vl.s
    lib/CMSIS/Core/CM3/: system_stm32f10x.c
  group Other
    ./: readme.txt
    config/: STM32F10x_FLASH.icf
  group StdPeriph_Driver
    lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Vectors
    src/: stm32f10x_it.c
